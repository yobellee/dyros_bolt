Commit message: update

File: dyros_bolt_description/robots/bolt_with_passive.urdf (robot description, URDF)
Before this commit: robot bolt, 10 links, 9 joints
Links:
- removed link world
Joints:
- removed joint virtual
